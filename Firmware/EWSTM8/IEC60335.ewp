# IAR project IEC60335.ewp, settings and files
configuration IEC60335 STM8S105x (STM8)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x400
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\Libraries\STM8_SelfTest_Library\inc; ..\Libraries\STM8S_StdPeriph_Driver\inc; ..\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: IEC60335.srec
  ILINK.IlinkOutputFile: IEC60335.out
  ILINK.IlinkIcfFile: lnkstm8s105xx.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IEC60355 STM8S005x (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: STM8S005
  ICCSTM8.CCIncludePath2: ..\..\..\Middlewares\STM8_SelfTest_Library\inc; ..\..\..\Projects\STM8AS128_EVAL\inc
  ILINK.IlinkIcfFile: lnkstm8s005xx.icf
configuration IEC60335 STM8A626x (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF6268 STM8AF6268
  ICCSTM8.CCDefines: STM8AF626x
  ICCSTM8.CCIncludePath2: as above
  ILINK.IlinkIcfFile: lnkstm8af32k.icf
  group EWARM
    ../src/: cstartup.s
  group SelfTestLib
    ../Libraries/STM8_SelfTest_Library/src/: stm8_stl_clockrun.c stm8_stl_clockstart.c stm8_stl_cpurun_IAR.asm stm8_stl_cpustart_IAR.asm stm8_stl_crc16_IAR.c stm8_stl_crcrun.c stm8_stl_fullRam_IAR.asm stm8_stl_main.c stm8_stl_startup.c stm8_stl_transpRam.c
  group Source Files
    ../src/: main.c stm8s_it.c
